# Keil uVision project lib_XPT2046_ILI9325.uvprojx, settings and files
target lib_XPT2046_ILI9325 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_XPT2046_ILI9325 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx
  c include: .\inc;..\lib_ILI9325\inc;..\lib_STM32F407_StdPeriph\inc;..\lib_delay\inc;..\lib_usart\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: XPT2046_ILI9325.c
  group inc
    ./inc/: XPT2046_ILI9325.h
