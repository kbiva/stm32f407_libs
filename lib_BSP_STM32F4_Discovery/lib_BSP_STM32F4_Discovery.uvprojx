# Keil uVision project lib_BSP_STM32F4_Discovery.uvprojx, settings and files
target lib_BSP_STM32F4_Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_BSP_STM32F4_Discovery (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\inc;..\lib_STM32F407_StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./inc/: stm32f4_discovery.h stm32f4_discovery_lis302dl.h stm32f4_discovery_audio_codec.h
  group src
    ./src/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c stm32f4_discovery_audio_codec.c
