# Keil uVision project lib_tjpegd.uvprojx, settings and files
target lib_tjpegd (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_tjpegd (library)
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: tjpgd.c
  group inc
    ./inc/: tjpgd.h integer.h
